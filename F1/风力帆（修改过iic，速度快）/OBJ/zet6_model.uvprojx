# Keil uVision project zet6_model.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\OLED;..\SYSTEM;..\HARDWARE\DMP;..\HARDWARE\CONTROL;..\HARDWARE\DMP;..\HARDWARE\IIC;..\HARDWARE\MPU6050;..\HARDWARE\OLED;..\HARDWARE\TTP229
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/TTP229/: TTP229.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/: DataScope_DP.C
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_tim.c
